# Keil uVision project 工程文件.uvprojx, settings and files
target 工程 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 工程文件 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\USER;..\HARDWARE\inc;..\CORE;..\STLIB\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c
  group HARDWARE
    ../HARDWARE/scr/: delay.c usart1.c timer4.c stm32f10x_it.c usart2.c led.c wifi.c mqtt.c timer3.c timer1.c key.c iic.c bsp_tempad.c timer2.c bsp_dht11.c core_delay.c
  group CORE
    ../CORE/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
  group STLIB
    ../STLIB/src/: misc.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_gpio.c stm32f10x_exti.c stm32f10x_adc.c stm32f10x_dma.c
